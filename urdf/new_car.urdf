Commit message: robot_sim -v1.1 -20210414

File: urdf/new_car.urdf (robot description, URDF)
Before this commit: robot new_car, 3 links, 2 joints
Joints:
- joint footprint2base: origin xyz=0 0 0.001 -> xyz=0 0 0.05
